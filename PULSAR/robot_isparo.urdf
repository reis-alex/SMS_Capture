Commit message: new files

File: PULSAR/robot_isparo.urdf (robot description, URDF)
Before this commit: robot pulsar, 14 links, 13 joints
Links:
- link Link_6_: mass 0.924 -> 300
