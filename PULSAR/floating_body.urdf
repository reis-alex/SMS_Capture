Commit message: new files

File: PULSAR/floating_body.urdf (robot description, URDF)
Before this commit: robot free_body_with_dummy_joint, 2 links, 1 joints
Links:
- link body_link: mass 1.0 -> 10
